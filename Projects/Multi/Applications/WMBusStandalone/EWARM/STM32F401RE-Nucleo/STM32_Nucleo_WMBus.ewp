# IAR project STM32_Nucleo_WMBus.ewp, settings and files
configuration Meter-868MHz (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_STM32F4XX_NUCLEO; STM32F401xE; NO_EEPROM; SPIRIT1_ST_SHIELD; USE_SPIRIT1_DEFAULT
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library\Appli\Inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library\Inc; ..\..\..\..\..\..\Middlewares\ST\WMBUS_Library\RF_hal\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_Nucleo_WMBus.hex
  ILINK.IlinkOutputFile: STM32_Nucleo_WMBus.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xe.s
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/iar/: startup_stm32l053xx.s
  group Application/User
    ../../Src/: cube_hal_f4.c cube_hal_l0.c main.c radio_hal.c stm32f4xx_it.c stm32l0xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component/spirit1/SPIRIT1_Library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/BSP/Component/spirit1/SPIRIT1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
  group Drivers/BSP/STM32F4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c system_stm32l0xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c
  group Middlewares/WMBus_Library/Appli/Src
    ../../../../../../Middlewares/ST/WMBUS_Library/Appli/Src/: aes128.c aes128_ctr.c wmbus_appli.c
  group Middlewares/WMBus_Library/Library
    ../../../../../../Middlewares/ST/WMBUS_Library/Library/: SPIRIT1_WMBus_Library108_CM0_IAR.a SPIRIT1_WMBus_Library108_CM4_IAR.a
  group Middlewares/WMBus_Library/Link_Phy
    ../../../../../../Middlewares/ST/WMBUS_Library/Inc/: wmbus_crc.h wmbus_link.h wmbus_linkServices.h wmbus_phy.h

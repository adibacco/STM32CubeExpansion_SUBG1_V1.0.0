# Keil uVision project Project.uvprojx, settings and files
target STM32_Nucleo_WMBus-Meter-868MHz (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Meter-868MHz +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_STM32L0XX_NUCLEO,STM32L053xx,NO_EEPROM,SPIRIT1_ST_SHIELD,USE_SPIRIT1_DEFAULT
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc;..\..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Middlewares\ST\WMBUS_Library\Appli\Inc;..\..\..\..\..\..\Middlewares\ST\WMBUS_Library\Library\SPIRIT1_WMBus_Library.lib;..\..\..\..\..\..\Middlewares\ST\WMBUS_Library\Link\Inc;..\..\..\..\..\..\Middlewares\ST\WMBUS_Library\Inc
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l053xx.s
  group Application/User
    ../../Src/: cube_hal_l0.c main.c radio_hal.c stm32l0xx_it.c
  group Docs
    ../../: readme.txt
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/BSP/STM32L0xx_NUCLEO
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/Spirit1_Driver/SPIRIT1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Middlewares/ST/WMBUS_Library/Appli/Src
    ../../../../../../Middlewares/ST/WMBUS_Library/Appli/Src/: aes128.c aes128_ctr.c wmbus_appli.c
  group Middleware/ST/WMBUS_Library/Library
    ../../../../../../Middlewares/ST/WMBUS_Library/Library/: SPIRIT1_WMBus_Library108_CM0_Keil.lib
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_gpio.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pwr.c stm32l0xx_hal_rcc.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c
  group Drivers/BSP/Spirit1_Driver/SPIRIT1_Library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
